# IAR project Mock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: D:\D19 PTIT\Thuc tap\FPT\Mock\source; D:\D19 PTIT\Thuc tap\FPT\Mock\MKL46Z; D:\D19 PTIT\Thuc tap\FPT\Mock\CMSIS\Include; D:\D19 PTIT\Thuc tap\FPT\Mock\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mock.srec
  ILINK.IlinkOutputFile: Mock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../lib/: app.c app.h gpio.c gpio.h interrupt.c interrupt.h PWM.c PWM.h system.c system.h uart.c uart.h
  group source
    ../source/: main.c
  group startup
    ../MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
